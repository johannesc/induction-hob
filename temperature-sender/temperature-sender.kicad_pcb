# Repository johannesc/induction-hob

File README.md:

induction-hob
=============
This is the source code for the Android part of my hack to control my Induction hob from my phone using Bluetooth. Also see my fork of the ioio project. See http://johannesc.github.io/induction-hob/ for more information.

## KiCad design temperature-sender/temperature-sender.kicad_pcb

Parts:
C1: 1uF; C_0603_HandSoldering
C2, C4, C5, C6, C8, C9: 10uF; C_0603_HandSoldering
C3, C10: 0.1uF; C_0603_HandSoldering
D1, D2, D4, D5: D; SOD-80
D3: Led_Small; LED-0603
IC1: ATTINY2313A-S; SOIC-20_7.5x12.8mm_Pitch1.27mm
K1: SERVO; Pin_Header_Angled_SMD_1x03
P1: ISP; Socket_Strip_Straight_2x03
P2: CONN_01X02; Pin_Header_Angled_SMD_1x02
P3, P5: CONN_01X03; Pin_Header_Angled_SMD_1x03
P4: CONN_01X04; Pin_Header_Angled_SMD_1x04
P6, P7: 03mmTo05mm
R1, R7: 47k; R_0603_HandSoldering
R2: 330R; R_0603_HandSoldering
R3: 240R; R_0603_HandSoldering
R4: 1k5; R_0603_HandSoldering
R5, R6: 47R; R_0603_HandSoldering
R8, R9, R10: 5k; R_0603_HandSoldering
SW1, SW2: SW_PUSH; 4x4x1.5mm_Tactile_Push_Button_SMD
TP_PB1, TP_PB2, TP_PB3: TEST_POINT; TP_1mm
TP_PD1, TP_PD2, TP_PD3: TEST_POINT; TP_1mm
TP_XTAL1, TP_XTAL2: TEST_POINT; TP_1mm
U1: AMS1117; SOT-223
U2: LM317L; TO-92_Inline_Narrow_Oval
U3: TMP102; SOT563

Connections:
+3V3: C2.1, C9.1, IC1.20 (VCC), P1.2, P4.2, P5.2, R1.1, R2.1, R6.2, R7.1, R8.1, R9.1, U1.2 (VOUT), U1.4 (VOUT)
/9v: C4.1, C5.1, C6.1, R3.2, U1.3 (VIN), U2.2 (OUT)
/MISO: IC1.18 ((PCINT6/MISO/DO)PB6), P1.1
/RESET: C10.1, IC1.1 (PA2(~RESET~/dW/PCINT10)), P1.5, R7.2, SW2.2
/RF_DATA: IC1.14 ((PCINT2/OC0A)PB2), P5.3
/RX: IC1.2 ((PCINT11/RXD)PD0), P3.3
/SCL: IC1.19 ((PCINT7/USCK/SCK/SCL)PB7), P1.3, P4.4, R9.2
/SDA/MOSI: IC1.17 ((PCINT5/MOSI/DI/SDA)PB5), P1.4, P4.3, R8.2
/SERVO1: IC1.15 ((PCINT3/OC1A)PB3), R5.2
/SERVO_PWR: C8.1, K1.2 (VCC), R6.1
/SERVO_SIG: K1.3 (SIG), R5.1
/SW: C3.2, IC1.7 ((PCINT14/INT1)PD3), R1.2, SW1.1
/TX: IC1.3 ((PCINT12/TXD)PD1), P3.2
/Vadj: R3.1, R4.2, U2.1 (ADJ)
/Vin1: D1.2 (A), D5.1 (K), P2.2
/Vin2: D2.2 (A), D4.1 (K), P2.1
/Vin_rec: C1.1, D1.1 (K), D2.1 (K), U2.3 (IN)
GND: C1.2, C2.2, C3.1, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, D3.1 (K), D4.2 (A), D5.2 (A), IC1.10 (GND), K1.1 (GND), P1.6, P3.1, P4.1, P5.1, R4.1, SW1.2, SW2.1, U1.1 (GND); also elsewhere on the board
unnamed: D3.2 (A), R2.2
unnamed 19: R10.2; also elsewhere on the board
unnamed: IC1.4 (PA1(XTAL2/PCINT9)), TP_XTAL1.1
unnamed: IC1.5 (PA0(XTAL1/CLKI/PCINT8)), TP_XTAL2.1
unnamed: IC1.8 ((PCINT15/T0)PD4), TP_PD1.1
unnamed: IC1.9 ((PCINT16/OC0B/T1)PD5), TP_PD2.1
unnamed: IC1.11 ((PCINT17/ICPI)PD6), TP_PD3.1
unnamed: IC1.12 ((PCINT0/AIN0)PB0), TP_PB1.1
unnamed: IC1.16 ((PCINT4/OC1B)PB4), TP_PB3.1

Notes on the sheet:
Temp sensor
ADDR0 to V+ => Device address = 1001001
Debug UART
433MHz Tx module
Vout = 1.25*(1+R2/R1) Vout = 1.25*(1+1500/240) Vout = 9v

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
Board: 2 copper layers, 44 parts (18 on the bottom side), 29 nets, no tracks yet.

Other parts of the board:
D6: Led_Small; LED-0603
GND1: TEST_POINT; SolderWirePad_single_1mmDrill

Their connections:
GND: D6.1, GND1.1; also elsewhere on the board
unnamed 19: D6.2; also elsewhere on the board

## Commit log

2012-12-13 Initial import to git
    This project contains files created
    while trying to add Bluetooth to my
    Electrolux EHD7660P induction hob.
2012-12-17 First import of software
    Simple Java program to control the
    induction hob, not yet fully working.
2013-01-09 Fixed PC test program so that it works
    The PC test program can now control the
    induction hob if the keyboard is removed.
    TODO:
    * Add timer that resends the power command
    every 10 seconds.
    * Make sure we wait for an ack before we
2013-01-10 Clean up source
    * Use UNIX file endings
    * Remove trailing white spaces
    * Add some annotations
2013-01-10 Add timer that resends power command every 10s
    The power card will turn off if it does not
    receive a power command every now and then.
    Also make sure we only access the UI stuff
    from the UI thread. Also some other small
    changes. Everything more or less untested.
2013-01-10 Separate OS specific things
    Prepare so that the inductionlib can be used
    from an IOIO Android project. Untested.
2013-01-11 Clean up debug prints and add time check
    * Collect all debug prints into a couple of methods
    which makes it easier to turn them off.
    * Make sure a packet is received within 100ms
2013-01-11 Wait for ack and resend packets
    Wait for ack when sending commands. If
    not received within some time resend it.
    Not tested.
2013-01-16 Small cleanup
    Commit to be in sync...
2013-04-29 Some more reverse engineering
    Started measure with oscilloscope, seems
    to get funny measurements. Will have to do
    them again.
2013-06-09 Add schematics for the adapter between ioio and the induction hob
    A shift register keeps track of the shift register in the left
    keyboard/display. The IOIO samples the value when STCP (RCLK)
    goes high. The shift register on the right keyboard/display
    seems to get the same values but with Q3 (QD) (connected to
    INH on the 4051) inverted. Thise makes it possible to emulate
    key presses on the right keybaord/display as well.
2013-06-14 Increase packet timeout for Bluetooth
    It seems to be more delays over Bluetooth sometimes. Lets
    increase the packet timeout a bit.
2013-06-14 Use INT1 instead of CN interrupt
    This will make the interrupt routine faster since there is no
    need to check which pin that caused the interrupt and if it was
    a positive or negative flank.
2013-06-14 Added screenshots from the oscilloscope for touch buttons
    In these screenshots you can see how the induction hob detects
    when a finger "presses" any of the touch buttons. It is a quite
    small difference in the voltage that is required.
2013-06-14 Restructered source code
    Renamed packages and moved them around a bit to get a cleaner
    structure.
2013-06-14 Added .gitigore file
2013-06-14 Correct size of array
    We like to have power levels of all zones.
2013-06-14 Add a simple PC test program using the ioio and adapter card
    Basic stuff works.
2013-07-01 Checking keyboard interaction
    Totally untested code..
2013-07-06 Add screen shot for entire scan of all buttons
    Here you can also see the background light affecting the
    analog value. The trigger point is when scanning the power
    button and you can see that it seems like the power button
    is connected to another analog input.
2013-07-06 Less verbose debug printing
    Removed some debug prints. I shuould realy
    start to categorize the prints...
2013-07-07 Clean up code a bit and break common things out
    Also add support to abort ongoing control if user
    has pressed a button on that zone.
2013-07-08 Only control hob if a pot is present or current level is 0
    The potPresent can only be "trusted" if the current power
    level is > 0. If we control the zone without a pot it will
    automatically shut off.
2013-07-08 Wait longer when clock button is pressed
    If the user presses the clock button and we start pressing
    + or - we might instead change the time. Also remove the
    compensation of our pressed mask since that was moved to
    the ioio firmware.
2013-07-08 Support controlling of several zones
    We can only control one zoe at a time and wee need some time
    between different key presses.
2013-07-15 Read temperature from barbeque thermometer
    Do nothing with the values for now. In the future this will be
    used to regulate the temperature.
2013-07-20 Add temperatur input and simple controller
    A first very ugly working program that can heat up thing and
    adjust the power level on the induction hob.
2013-07-27 First working version of Android application
    A lot of ugly code, but basic functionality is there.
    The UI is very simple and rotation does not work
    properly.
2013-07-31 Code works a bit better
    Still lokks quite ugly, can't handle screen rotation
    and a lot of other things to be fixed.
2013-08-08 Using a service instead of an activity
    Makes things work so much better. The activity can
    be paused and stopped and the program still continues to
    work. Also removed some debug things and displaying the
    connected state in the ui.
2013-08-08 Make the UI look better and more user friendly
    Create a SeekBar for each zone and show the current value
    separate from the target value. Also show the power level
    under the SeekBars. A lot of things still to be done.
2013-08-14 Better handling of notification and exit of application
    Show temperature in the notification bar. Also show the UI
    instead of exiting the sevice when clicking on it. The
    notification is now shown from the activity instead of
    the service.
2013-08-14 Faster control of power
    User the "P" button to reach the P-level and
    "+" and "-" at the sema time to reach 0 level.
2013-08-14 Show when the program has finished
    Make sure it is visible in the app when a program
    has finished.
2013-08-15 Fix faster power control for level 0
    The if-cases were in the wrong order.
2013-08-15 Break out controllers from the zone
    Also move the setting of button mask.
2013-08-15 Improve temperature sensor handling
    Handle more than one in some cases and handle
    invalid readings.
2013-10-10 A bunch of fixes and some new bugs
    Show several temperatures, only landscape and tweaked
    milkcontroller. Seems to be a problem when app
    is minimized.
2013-11-20 New icons, fix resume from status bar
    Also drop old temperature readings.
2013-11-20 Add documentation
    A document describing the project.
2013-11-30 Add ioio-adapter/ioio-adapter.svg
    Will be used on wiki.
2013-11-30 Create gh-pages branch via GitHub
2013-11-30 Adding some pictures and svg files
    Making sure .svg files work correctly
2013-11-30 Some doc
    Still need some tweaking in the formatting, that might
    happen some time in the future.
2013-12-02 Add missing link and picture
    Forgot to add them
2013-12-02 Some corrections and a screenshot of the Android app
    Actually read the text...
2013-12-02 Add a favicon...
    Using my very nice icon from my Android app.
2013-12-02 Add hackaday inspiration link
    Because I like them :)
2013-12-04 Fix some warnings and errors reported by http://validator.w3.org
    The title says it all...
2013-12-04 Make smaller images display next to each other
    Don't ask how I did it, but it works. Also increased max-witdth
    by 10 pixels so that two oscilloscope images fit next to each
    other.
2014-06-28 Various UI fixes
    * Red/Blue dot in SeekBar for hot pot
    * Indicate pot present
    * Rename app
2014-06-28 Readme.md: Add link to gh-pages
2014-06-28 Fix clock press timing
    If the user has pressed the clock we must wait for the hob to leave
    the "clock mode" before trying to simulate presses otherwise we might
    end up changing the time of the clock instead of the power level. This
    almost worked, but did not take into consideration that the hob stays
    in "clock mode" while adjusting the time. Solve this by only clearing
    the "clock mode" once we have got ok to press a button.
2014-06-28 Add support for two temperature sensors
    Also control based on temperature of the pot itself, not just the
    contents temperature. This makes it possible to avoid the milk to
    burn at the surface of the pot.
2014-10-15 New fancier UI
    Instead of showing seekbars for every zone pop it up when pressing
    the zone. Also upgrade ecplise.
    Some features (e.g. zone hot, target vs current level) are not
    supported yet.
    Also support program on every zone.
2014-11-16 A lot of changes
    Next time I promise to make several isolated commits.
2014-11-23 Make layout a bit bigger and avoid so many hardcoded dimensions
    By using TableLayout and layout_weight.
2014-11-23 Make the ZoneDialog wider
    Also make the slider wider when the dialog is wider and always
    occupy a fixed width for the temperature next to the temperature
    slider. The supported temperature range is now 30-150 degrees.
2014-11-23 Remove white background from seekbar
2015-05-05 Changes after opening in KiCad 0.201505041002+5641~23~ubunto14.04.1-product
    I previously used kicad 0.20131208+bzr4024-1ubuntu2. Some other changes
    might also not have been committed before.
2015-05-08 Add kicad files for temperature sender card
    Initial import, using ATmega32u4
2015-05-16 More changes to temperature-sender
2015-06-11 Some more changes to temperature sender
2015-06-23 Some more changes, slowly getting there
2015-07-01 Components placement mostly done
    Problem with small temperature footprint. I like to have wider
    power traces, but then it can't route this chip. Must figure out how
    to solve it in KiCad.
2015-07-08 Temperature sender before import freerouting results
2015-07-08 Added plot files
    Ready to order.
2015-07-08 Temperature sensor as ordered
2015-07-08 Unknown changes, probably what I ordered
2015-11-02 First simple firmware for temperature sender PCB
    Very simple first program that turn on LED_D6 when
    pressing SW1.
2015-11-09 Clean up code and add some basic UART test
    Use defines to make the code easier to read, add a delay
    macro (very approximate busy wait) and print a test string
    on the UART @ 9600bps.
2016-01-31 Adding code to read the TMP102 sensor
    The code uses the AVR310 application note.
2016-01-31 Changed a couple of resistors on the temperature-sender
    I did not have the exact values, so I changed to closest
    match.
2016-01-31 Add eclipse project files
    Using plugin from http://avr-eclipse.sourceforge.net/updatesite/
